.INCLUDE"M32DEF.INC"
.ORG 0x00
LDI R16,HIGH(RAMEND)
OUT SPH,R16
LDI R16, LOW(RAMEND)
OUT SPL,R16

LDI R16,0xFF
OUT DDRD,R16
	LOOP:
		LDI R16,0b00000101
		OUT PORTD,R16
		CALL DELAY
		LDI R16,0b00000001
		OUT PORTD,R16
		CALL DELAY
		LDI R16,0b00000000
		OUT PORTD,R16
		CALL DELAY
		LDI R16,0b00000100
		OUT PORTD,R16
		CALL DELAY
		RJMP LOOP
	DELAY:
		
    ldi  r18, 2
    ldi  r19, 75
L1: dec  r19
    brne L1
    dec  r18
    brne L1


	RET
